PACKAGECONFIG:remove = "clients screenshare shell-desktop shell-fullscreen shell-ivi wayland x11 xwayland"
PACKAGECONFIG:append = " kms egl systemd shell-kiosk"
